## net/wireguard/Kconfig
```kconfig
config WIREGUARD
	tristate "WireGuard (ATU: stub, disabled)"
	default n

config WIREGUARD_DEBUG
	bool
	default n
```
